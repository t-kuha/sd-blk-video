SRC_URI += "file://user_2020-09-19-06-50-00.cfg \
            file://user_2020-09-19-07-43-00.cfg \
            file://user_2020-09-19-08-08-00.cfg \
            file://user_2020-09-19-08-31-00.cfg \
            file://user_2020-09-21-13-09-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

